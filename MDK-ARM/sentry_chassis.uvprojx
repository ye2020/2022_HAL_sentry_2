# Keil uVision project sentry_chassis.uvprojx, settings and files
target sentry_chassis (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: sentry_chassis +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\TASK\Task_Chassis; ..\TASK\Task_Detect; ..\TASK\Task_Fire; ..\TASK\Task_Gimbal; ..\TASK\Task_Safe; ..\SYSTEM\SysInit; ..\TASK\Task_Led; ..\CONTROL\RemoteControl; ..\SYSTEM\bsp_usart2; ..\SYSTEM\FIFO_BUFF; ..\ALGORITHM\rmmotor; ..\CONTROL\CAN_1_Receive; ..\ALGORITHM\pid; ..\ALGORITHM\maths; ..\ALGORITHM\list_of_function; ..\ALGORITHM\math_filter; ..\CONTROL\chassis_app; ..\CONTROL\gimbal_app; ..\CONTROL\chassis_behaviour; ..\CONTROL\gimbal_behaviour; ..\CONTROL\CAN_2_Receive
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c rng.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group ALGORITHM
    ../ALGORITHM/rmmotor/: rmmotor.c
    ../ALGORITHM/pid/: pid.c
    ../ALGORITHM/maths/: maths.c
    ../ALGORITHM/list_of_function/: list_of_function.h
    ../ALGORITHM/math_filter/: filter.c
  group CONTROL
    ../CONTROL/RemoteControl/: RemoteControl.c
    ../CONTROL/CAN_1_Receive/: CAN_1_Receive.c
    ../CONTROL/chassis_app/: chassis_app.c
    ../CONTROL/gimbal_app/: gimbal_app.c
    ../CONTROL/chassis_behaviour/: chassis_behaviour.c
    ../CONTROL/gimbal_behaviour/: gimbal_behaviour.c
    ../CONTROL/CAN_2_Receive/: CAN_2_Receive.c
  group TASK
    ../TASK/Task_Chassis/: Task_Chassis.c
    ../TASK/Task_Fire/: Task_Fire.c
    ../TASK/Task_Gimbal/: Task_Gimbal.c
    ../TASK/Task_Safe/: Task_Safe.c
    ../TASK/Task_Detect/: Task_Detect.c
    ../TASK/Task_Led/: Task_LED.c
  group SYSTEM
    ../SYSTEM/SysInit/: SysInit.c
    ../SYSTEM/bsp_usart2/: bsp_usart2.c
    ../SYSTEM/FIFO_BUFF/: fifo_buff.c
software components: CMSIS:CORE 5.5.0
